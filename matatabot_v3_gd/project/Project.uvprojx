# Keil uVision project Project.uvprojx, settings and files
target matatabot (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F330K8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x02000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: matatabot
  AfterMake: fromelf --bin ".\Objects\@L.axf" --output ".\Objects\@L.bin"
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\src;..\src\driver;..\GD32F3x0_library\CMSIS;..\GD32F3x0_library\CMSIS\GD\GD32F3x0\Source\ARM;..\GD32F3x0_library\CMSIS\GD\GD32F3x0\Include;..\GD32F3x0_library\GD32F3x0_standard_peripheral\Include;..\src\communication;..\src\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group GD32F3x0_library
    ../GD32F3x0_library/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    ../GD32F3x0_library/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
    ../GD32F3x0_library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_rcu.c gd32f3x0_misc.c gd32f3x0_dac.c gd32f3x0_exti.c gd32f3x0_syscfg.c gd32f3x0_fmc.c gd32f3x0_dma.c gd32f3x0_timer.c gd32f3x0_usart.c gd32f3x0_gpio.c gd32f3x0_adc.c
  group src
    ../src/: main.c
  group src/driver
    ../src/driver/: drv_gpio.c drv_gpio.h drv_ring_buf.c drv_ring_buf.h drv_systime.c drv_systime.h drv_uart.c drv_uart.h drv_oid.c drv_step_motor.c drv_key.c drv_led.c drv_sensor.c drv_motor.c drv_exit.c drv_pwm.c drv_motor_control.c drv_time.c drv_command.c drv_receive_buff.c drv_ringbuf.c
  group src/communication
    ../src/communication/: communication_link.c communication_link.h message.c
  group common
    ../src/common/: crc16.c
